## dispenser/build/Kconfig/boards/Kconfig.defconfig
```kconfig
# Load Zephyr board defconfig descriptions.
osource "/home/samue/csse4011/zephyr/boards/seeed/xiao_ble/Kconfig.defconfig"
```
